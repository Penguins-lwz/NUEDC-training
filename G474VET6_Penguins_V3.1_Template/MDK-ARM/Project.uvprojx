# Keil uVision project Project.uvprojx, settings and files
target Project (6220000::V6.22::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS-DSP/Include;../Drivers/CMSIS-DSP/PrivateInclude;../BSP/Inc;../Algo/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dac.c dma.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application/User/BSP
    ../BSP/Src/: font.c lcd.c ad9833.c ad9959.c
  group Application/User/Algo
    ../Algo/Src/: fir.c fft.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_dac.c stm32g4xx_hal_dac_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Drivers/CMSIS-DSP
    ../Drivers/CMSIS-DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../Drivers/CMSIS-DSP/Source/BayesFunctions/: BayesFunctions.c
    ../Drivers/CMSIS-DSP/Source/CommonTables/: CommonTables.c
    ../Drivers/CMSIS-DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../Drivers/CMSIS-DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../Drivers/CMSIS-DSP/Source/DistanceFunctions/: DistanceFunctions.c
    ../Drivers/CMSIS-DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../Drivers/CMSIS-DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../Drivers/CMSIS-DSP/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../Drivers/CMSIS-DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../Drivers/CMSIS-DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../Drivers/CMSIS-DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../Drivers/CMSIS-DSP/Source/SupportFunctions/: SupportFunctions.c
    ../Drivers/CMSIS-DSP/Source/SVMFunctions/: SVMFunctions.c
    ../Drivers/CMSIS-DSP/Source/TransformFunctions/: TransformFunctions.c
    ../Drivers/CMSIS-DSP/Source/WindowFunctions/: WindowFunctions.c
software components: CMSIS:CORE 6.1.0
